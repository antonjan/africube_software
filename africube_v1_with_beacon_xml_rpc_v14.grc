options:
  parameters:
    author: root
    generate_options: qt_gui
    id: africube_v1_with_beacon_xml_rpc_14
    output_language: python
    run_options: run
    title: Test Rpitx
  states: {}

blocks:
- name: Beacon_mixer_gain
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: Beacon_mod_gain
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: Beacon_overall_gain
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: LPF_rf_gain_0
  id: variable
  parameters:
    value: '9'
  states: {}
- name: SDR_rf_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: beacon_Preemphasis
  id: variable
  parameters:
    value: '-1'
  states: {}
- name: beacon_bpf_high_cutoff
  id: variable
  parameters:
    value: '31000'
  states: {}
- name: beacon_bpf_low_cutoff
  id: variable
  parameters:
    value: '21000'
  states: {}
- name: beacon_deviation
  id: variable
  parameters:
    value: 2.5e3
  states: {}
- name: beacon_int_phase
  id: variable
  parameters:
    value: '0'
  states: {}
- name: beacon_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: beacon_offset_freq
  id: variable
  parameters:
    value: '-24800'
  states: {}
- name: beacon_tau
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: command_agc_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: command_agc_max_gain
  id: variable
  parameters:
    value: '5'
  states: {}
- name: command_agc_rate
  id: variable
  parameters:
    value: '1e-4'
  states: {}
- name: command_agc_ref
  id: variable
  parameters:
    value: '1'
  states: {}
- name: command_costas_loop_bw
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: command_costas_loop_order
  id: variable
  parameters:
    value: '2'
  states: {}
- name: command_freq_decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: command_freq_ofset
  id: variable
  parameters:
    value: '-35e3'
  states: {}
- name: command_max_dev
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: command_taps_cutoff_freq
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: command_tau
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: command_trans_witdth_freq
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: fun_proibe_rx_level
  id: variable_function_probe
  parameters:
    block_id: rx_level_probe
    function_name: level
    poll_rate: '0.1'
    value: '0'
  states: {}
- name: low_pass_filter_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: lpf_cutoff_freq
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: '435100000'
  states: {}
- name: rx_level
  id: variable
  parameters:
    value: convert_complex_to_string.convert_complex_to_string(fun_proibe_rx_level)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48000*2
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '1248000'
  states: {}
- name: sdrplay_rx_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: tran_tx_freq
  id: variable
  parameters:
    value: '145970000'
  states: {}
- name: variable_low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: command_taps_cutoff_freq
    gain: '1.0'
    samp_rate: samp_rate
    width: command_trans_witdth_freq
    win: firdes.WIN_HAMMING
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: sdrplay rf gain
    orient: Qt.Horizontal
    start: '-30'
    step: '1'
    stop: '30'
    value: '9'
  states: {state: disabled}
- name: variable_qtgui_range_0_0
  id: variable_qtgui_range
  parameters:
    label: lpf rf gain
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '100'
    value: '1'
  states: {state: disabled}
- name: variable_qtgui_range_0_0_0
  id: variable_qtgui_range
  parameters:
    label: Beacon mixer Gain
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '2'
    value: '0.8'
  states: {state: disabled}
- name: variable_qtgui_range_0_0_0_0
  id: variable_qtgui_range
  parameters:
    label: Beacon mod gain Gain
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '2'
    value: '0.8'
  states: {state: disabled}
- name: variable_qtgui_range_0_0_0_0_0
  id: variable_qtgui_range
  parameters:
    label: Beacon Gain
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '2'
    value: '0.088'
  states: {state: disabled}
- name: variable_qtgui_range_1
  id: variable_qtgui_range
  parameters:
    label: deviastion
    orient: Qt.Horizontal
    start: '1000'
    step: '1'
    stop: '25000'
    value: '5000'
  states: {state: disabled}
- name: variable_rx_level_label
  id: variable_qtgui_label
  parameters:
    label: Rx Level
    type: int
    value: fun_proibe_rx_level
  states: {state: disabled}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: command_agc_gain
    max_gain: command_agc_max_gain
    rate: command_agc_rate
    reference: command_agc_ref
    type: complex
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    comment: variable_qtgui_range_1
    max_dev: command_max_dev
    quad_rate: '96000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: beacon_Preemphasis
    max_dev: beacon_deviation
    quad_rate: samp_rate
    tau: beacon_tau
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: ' 0.0654'
    min_freq: '-0.0654'
    w: '0'
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '100'
    threshold: variable_qtgui_range_1
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Beacon_mixer_gain
    freq: beacon_offset_freq
    offset: beacon_offset
    phase: beacon_int_phase
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:2,0,1
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:2,1,0
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: beacon_bpf_high_cutoff
    low_cutoff_freq: beacon_bpf_low_cutoff
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/32
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Beacon_mod_gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Beacon_overall_gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1500.0'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pi/africube_software/test_audio.wav
    repeat: 'True'
  states: {state: disabled}
- name: convert_complex_to_string
  id: epy_module
  parameters:
    source_code: |-
      # this module will be imported in the into your flowgraph
      #fun_proibe_rx_level

      def convert_complex_to_string(ob):
          
          strobj = str(complex(ob))
         
          return strobj
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '16'
    long_form: 'True'
    type: ff
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: command_costas_loop_order
    w: command_costas_loop_bw
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: command_freq_ofset
    decim: command_freq_decimation
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_cutoff_freq
    decim: '1'
    gain: LPF_rf_gain_0
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/32
    win: firdes.WIN_HAMMING
  states: {}
- name: python_sweeper
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      #https://www.youtube.com/watch?v=9bhmF7WRvMQ&t=182s
      f1 = 430000000
      f2 = 440000000
      f = f1
      step = 12000

      def sweeper(probe_lvl):
          if probe_lvl:
             f += step
          if f >= f2:f=f1
          return f
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '48000'
    type: float
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: rpitx_rpitx_source_0
  id: rpitx_rpitx_source
  parameters:
    carrier_freq: tran_tx_freq
    samp_rate: samp_rate
  states: {}
- name: rx_level_probe
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    args: driver=sdrplay
    balance0: '0'
    center_freq0: rx_freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dev: driver=sdrplay
    devname: custom
    overall_gain0: SDR_rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: '8008'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:50001
    timeout: '1500.0'
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://localhost:50241
    timeout: '100'
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [analog_agc_xx_0, '0', blocks_probe_rate_0, '0']
- [analog_agc_xx_0, '0', digital_costas_loop_cc_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_nbfm_rx_0, '0', dc_blocker_xx_0, '0']
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_mag_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_nbfm_rx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [audio_source_0, '0', analog_nbfm_tx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0, '0', rpitx_rpitx_source_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_1, print]
- [blocks_probe_rate_0, rate, zeromq_pub_msg_sink_0, in]
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [dc_blocker_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_costas_loop_cc_0, '0', analog_nbfm_rx_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_mag_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', blocks_add_xx_0, '1']
- [soapy_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_source_0, '0', low_pass_filter_0, '0']
- [soapy_source_0, '0', rx_level_probe, '0']
- [zeromq_pull_msg_source_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
