<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>aprs_rxtx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>device_name</key><value>hw:0,0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>device_name</key><value>hw:0,1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>bruninga_ax25_fsk_mod</key>
<param><key>id</key><value>bruninga_ax25_fsk_mod_0</value></param>
<param><key>baud_rate</key><value>1200</value></param>
<param><key>flag_count</key><value>10</value></param>
<param><key>mark_freq</key><value>2200</value></param>
<param><key>preamble_len_ms</key><value>300</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>space_freq</key><value>1200</value></param>
</block>
<block>
<key>bruninga_fsk_demod</key>
<param><key>id</key><value>bruninga_fsk_demod_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>bruninga_hdlc_to_ax25</key>
<param><key>id</key><value>bruninga_hdlc_to_ax25_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>bruninga_str_to_aprs</key>
<param><key>id</key><value>bruninga_str_to_aprs_0</value></param>
<param><key>dest</key><value>NOCALL</value></param>
<param><key>src</key><value>NOCALL</value></param>
<param><key>via</key><value>[]</value></param>
</block>
<block>
<key>digital_hdlc_deframer_bp</key>
<param><key>id</key><value>digital_hdlc_deframer_bp_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>500</value></param>
<param><key>min</key><value>15</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>enable loopback  sudo modprobe snd-aloop</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>FSK Audio output</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>FSK Audio input</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>bruninga_fsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>bruninga_str_to_aprs_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>bruninga_ax25_fsk_mod_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bruninga_ax25_fsk_mod_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bruninga_fsk_demod_0</source_block_id><sink_block_id>digital_hdlc_deframer_bp_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bruninga_str_to_aprs_0</source_block_id><sink_block_id>bruninga_ax25_fsk_mod_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_hdlc_deframer_bp_0</source_block_id><sink_block_id>bruninga_hdlc_to_ax25_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
